SUMMARY = "Bandaid ext4 for nocturne"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

BANDAID_VENDOR = "nocturne"
BANDAID_PACKAGES = "nocturned nocturne-ui"

inherit bandaid-image
